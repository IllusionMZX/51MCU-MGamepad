# Keil uVision project PLAY_GAME.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: PLAY_Game +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c oled.c oled_data.c bluetooth.c WS2812.c USART.c DMP.c MPU6050.c Soft_I2C.c tetris.c snake.c
